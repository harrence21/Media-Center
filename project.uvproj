# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800000
  memory RVCT9: RAM 0x10000000 size 0x80000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: startup_LPC17xx.s ADC.c ADC.h core_cm3.c core_cm3.h Font_6x8_h.h Font_16x24_h.h GLCD_SPI_LPC1700.c IRQ.c LED.c LPC17xx.h system_LPC17xx.h type.h KBD.h KBD.c main.c usbuser.h usbuser.c usbreg.h usbhw.h usbhw.c usbdmain.c usbdesc.h usbdesc.c usbcore.h usbcore.c usbcfg.h usbaudio.h usb.h audio.h adcuser.h adcuser.c GLCD.h LED.h game1.c game2.c system_LPC17xx.c
  group actual
    ./PZGAPM~2/: 220px-Basketball.c arrow .c bucket.c cherry.c whiteforbucket.c bmw1.c gtr.c redcup.c bomb.c bas.c
